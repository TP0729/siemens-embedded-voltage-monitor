# Keil uVision project Project.uvprojx, settings and files
target GD32470V_START (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470
  c include: .\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;.\GD32F4xx_Firmware_Library\CMSIS;.\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;.\Utilities;.\User;.\Driver;.\Driver\OLED;.\Protocol;.\Function
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./User/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ./GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ./GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_START
    ./Utilities/: gd32f470v_start.c
  group Startup
    ./GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Driver
    ./Driver/OLED/: oled.c oled.h oledfont.h
    ./Driver/: ADC.c ADC.h DAC.c DAC.h Delay.c Delay.h KEY.c KEY.h LED.c LED.h PWU.c PWU.h RTC.c RTC.h SPI_AD3344.c SPI_AD3344.h SPI_FLASH.c SPI_FLASH.h USART.c USART.h TIMER.c TIMER.h
  group Protocol
    ./Protocol/: Protocol.c Protocol.h
  group Function
    ./Function/: Function.c Function.h
software components: CMSIS:CORE 6.1.0
